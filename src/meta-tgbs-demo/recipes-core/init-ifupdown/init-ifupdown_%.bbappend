FILESEXTRAPATHS:prepend:zybo-z7 := "${THISDIR}/files:"
