FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:zybo-z7 = " file://zybo-z7.cfg"

