SUMMARY = "Placeholder recipe for the meta-kdebug layer"
DESCRIPTION = "Empty recipe used to keep meta-kdebug visible as a BitBake layer collection."
LICENSE = "CLOSED"

inherit allarch

ALLOW_EMPTY:${PN} = "1"
